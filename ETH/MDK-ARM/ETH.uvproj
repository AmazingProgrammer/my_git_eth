# Keil uVision project ETH.uvproj, settings and files
target ETH (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ETH
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc;    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Include;    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Middlewares/Third_Party/LwIP/src/include;   ../Middlewares/Third_Party/LwIP/system;   ../Middlewares/Third_Party/LwIP/src/include/lwip;   ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;   ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;   ../Middlewares/Third_Party/LwIP/src/include/netif;   ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;   ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;   ../Middlewares/Third_Party/LwIP/src/include/posix;   ../Middlewares/Third_Party/LwIP/src/include/posix/sys;   ../Middlewares/Third_Party/LwIP/system/arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_eth.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c
  group Application/User
    ../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c lwip.c ethernetif.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4.c dhcp.c ip_frag.c igmp.c icmp.c autoip.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: utils.c multilink.c pppos.c chap-new.c pppoe.c fsm.c ipcp.c lcp.c upap.c ppp.c pppol2tp.c magic.c chap_ms.c ipv6cp.c mppe.c auth.c chap-md5.c demand.c pppcrypt.c eui64.c ccp.c vj.c eap.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md4.c sha1.c des.c arc4.c md5.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c tcp.c stats.c tcp_out.c raw.c mem.c def.c dns.c pbuf.c netif.c udp.c inet_chksum.c sys.c init.c lwip_timers.c memp.c
    ../Middlewares/Third_Party/LwIP/src/api/: err.c netifapi.c sockets.c pppapi.c netdb.c netbuf.c tcpip.c api_msg.c api_lib.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ethip6.c icmp6.c ip6.c inet6.c ip6_addr.c mld6.c ip6_frag.c nd6.c dhcp6.c
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
